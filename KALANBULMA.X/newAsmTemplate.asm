    LIST P=16F877A
    #INCLUDE <P16F877A.INC>
    __CONFIG H'3F31'
    S1 EQU 0X24
    S2 EQU 0X25
    TEMP EQU 0X26
    ORG 0X00
MAIN
    BANKSEL ADCON1
    MOVLW 0X06
    MOVWF ADCON1
    BANKSEL TRISA
    BSF TRISA,0
    CLRF TRISB
    BANKSEL PORTB
    CLRF PORTB
    CLRF PORTA
    MOVLW 0X0F
    MOVWF S1
    MOVLW 0X06
    MOVWF S2
    CLRW
BUTON
    BTFSC PORTA,0
    GOTO ISLEM
    GOTO BUTON
ISLEM
    MOVFW S2
    SUBWF S1,F
    BTFSS STATUS,C
    GOTO GOSTER
    GOTO ISLEM
GOSTER
    MOVFW S2
    ADDWF S1,F
    MOVFW S1
    MOVWF PORTB
    END


