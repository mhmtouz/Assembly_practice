    LIST P=16F877A
    #INCLUDE <P16F877A.INC>
    S1 EQU 0X24
    S2 EQU 0X25
    T EQU 0X26
    BS1 EQU 0X27
    BS2 EQU 0X28
    ORG 0X00
    GOTO MAIN
MAIN
    BANKSEL TRISB
    CLRF TRISB
    BSF TRISD,0
    BANKSEL PORTB
    CLRF PORTB
    CLRF PORTD
    MOVLW 0X05
    MOVWF S1
    MOVLW 0X03
    MOVWF S2
    MOVWF T
    CLRW
BUTTON    
    BTFSS PORTD,0
    GOTO BUTTON
    GOTO ISLEM
ISLEM
    DECFSZ S1,F
    GOTO CARP
    GOTO SON
CARP
    MOVFW T
    ADDWF S2,F
    GOTO ISLEM
SON  
    MOVFW S2
    MOVWF PORTB
    END

    
    


