    LIST P=16F877A
    #INCLUDE <P16F877A.INC>
    SAYI1 EQU 0X24
    SAYI2 EQU 0X25
    ORG 0X000
    GOTO MAIN
MAIN
    BANKSEL TRISB
    CLRF TRISB
    BSF TRISD,0
    BANKSEL PORTB
    CLRF PORTB
    CLRF PORTD
    MOVLW D'1'
    MOVWF SAYI1
    MOVLW D'1'
    MOVWF SAYI2
BUTON
    BTFSS PORTD,0
    GOTO BUTON
    GOTO ISLEM
ISLEM
    MOVFW SAYI1
    ADDWF SAYI2
    MOVWF PORTB
    
    END
    


