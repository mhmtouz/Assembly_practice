    LIST P=16F877A
    #INCLUDE <P16F877A.INC>
    SAYI1 EQU 0X24
    SAYI2 EQU 0X25
    ORG 0X0000
    GOTO MAIN
MAIN
    BANKSEL TRISB
    CLRF TRISB
    BSF TRISC,1
    BANKSEL PORTB
    CLRF PORTB
    CLRF PORTC
    
    MOVLW D'6'
    MOVWF SAYI1
    MOVLW D'5'
    MOVWF SAYI2
    CLRW
BUTON
    BTFSS PORTC,1
    GOTO BUTON
    GOTO ISLEM
ISLEM
    ADDWF SAYI1,W
    DECFSZ SAYI2
    GOTO ISLEM
    MOVWF PORTB
    END


