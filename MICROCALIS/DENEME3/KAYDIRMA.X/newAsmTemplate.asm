    LIST P=16F877A
    #INCLUDE <P16F877A.INC>
    ORG 0X00
    GOTO MAIN
MAIN
    BANKSEL TRISB
    CLRF TRISB
    BSF PORTD,1
    BSF PORTC,1
    BANKSEL PORTD
    CLRF PORTB
    CLRF PORTC
    CLRF PORTD
    GOTO BUTON1
    GOTO SON  
BUTON1
    BTFSS PORTC,0
    GOTO BUTON2
    GOTO YAK1
BUTON2
    BTFSS PORTD,0
    GOTO BUTON1
    GOTO YAK2
YAK1
    RLF PORTB
    GOTO BUTON1
YAK2
    RRF PORTB
    GOTO BUTON2
SON 
    END
    
    
    
    


