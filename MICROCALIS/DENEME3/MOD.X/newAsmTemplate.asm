    LIST P=16F877A
    #INCLUDE <P16F877A.INC>
    
    SAYI1 EQU 0x20
    SAYI2 EQU 0x21
    ORG 0x00
    GOTO MAIN
MAIN
    BANKSEL TRISB
    CLRF TRISB
    BSF TRISD,0
    BANKSEL PORTB
    CLRF PORTB
    CLRF PORTD
    MOVLW D'13'
    MOVWF SAYI1
    MOVLW D'5'
    MOVWF SAYI2
BUTON
    BTFSS PORTD,0
    GOTO BUTON
    GOTO ISLEM
ISLEM    
    SUBWF SAYI1,F
    BTFSS STATUS,C
    GOTO MOD
    GOTO ISLEM
    GOTO SON
MOD
    ADDWF SAYI1,W
    MOVWF PORTB
SON
    END
    
    