    LIST P=16F877A
    #INCLUDE <P16F877A.INC>
    SAYI1 EQU 0X20
    SAYI2 EQU 0X21
    ORG 0X00
    GOTO MAIN
MAIN
    BANKSEL TRISB
    CLRF TRISB
    BSF TRISD,0
    BANKSEL PORTB
    CLRF PORTB
    CLRF PORTD
    MOVLW D'123'
    MOVWF SAYI1
    MOVLW D'13'
    MOVWF SAYI2
    CLRW
ISLEM
    MOVFW SAYI1
    SUBWF SAYI2
    BTFSS STATUS,C
    GOTO BYK
    GOTO KCK
BYK
    BSF PORTB,0
    GOTO SON
KCK
    BSF PORTB,1
    GOTO SON
SON    
    END

